# Keil uVision project ES320F654.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ES32F0654LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ES320F654
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ES32F065x
  c include: ..\Lib\ALD\ES32F065x\Include;..\Lib\CMSIS\Device\EastSoft\ES32F065x\Include;..\Lib\CMSIS\Include;..\APP;..\BSP;..\BSP\GPIO;..\BSP\KEY;..\BSP\TIMER;..\BSP\UART
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group BSP
    ../BSP/: bsp.c
    ../BSP/GPIO/: bsp_gpio.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/TIMER/: bsp_timer.c
    ../BSP/UART/: bsp_uart.c
  group LIB
    ../Lib/ALD/ES32F065x/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dma.c ald_flash.c ald_flash_ext.c ald_gpio.c ald_i2c.c ald_iap.c ald_pis.c ald_pmu.c ald_rmu.c ald_rtc.c ald_smartcard.c ald_spi.c ald_timer.c ald_trng.c ald_tsense.c ald_uart.c ald_usart.c ald_wdt.c utils.c
  group Src
    ../APP/: main.c irq.c
    ../Lib/CMSIS/Device/EastSoft/ES32F065x/System/: system_es32f065x.c
    ../Lib/CMSIS/Device/EastSoft/ES32F065x/Startup/keil/: startup_es32f065x.s
